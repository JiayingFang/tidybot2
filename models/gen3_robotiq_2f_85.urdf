Commit message: kinova eval & robot teleop

File: models/gen3_robotiq_2f_85.urdf (robot description, URDF)
Before this commit: robot gen3_robotiq_2f_85, 11 links, 10 joints
Joints:
- joint tool_frame_joint: origin xyz=0 0 0.120 rpy=0 0 0 -> xyz=0 0 0.148 rpy=0 0 0
